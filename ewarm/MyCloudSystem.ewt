<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>cloud</name>
    <file>
      <name>$PROJ_DIR$\..\cloud\cloud.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\cloud\cloud_connect.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\cloud\cloud_pal.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\cloud\device_status.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\cloud\smartconfig.c</name>
    </file>
  </group>
  <group>
    <name>common</name>
    <file>
      <name>$PROJ_DIR$\..\common\button_if.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\common\gpio_if.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\common\i2c_if.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\common\startup_ewarm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\common\timer_if.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\common\uart_if.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\common\udma_if.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\common\utils_if.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\common\wdt_if.c</name>
    </file>
  </group>
  <group>
    <name>driverlib</name>
    <file>
      <name>$PROJ_DIR$\..\driverlib\adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\aes.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\camera.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\cpu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\des.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\hwspinlock.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\i2s.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\interrupt.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\pin.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\prcm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\sdhost.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\shamd5.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\systick.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\timer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\udma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\utils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driverlib\wdt.c</name>
    </file>
  </group>
  <group>
    <name>FreeRTOS</name>
    <group>
      <name>MemMang</name>
      <file>
        <name>$PROJ_DIR$\..\FreeRTOS\source\MemMang\heap_3.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\FreeRTOS\source\croutine.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FreeRTOS\source\event_groups.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FreeRTOS\source\list.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FreeRTOS\source\ARM_CM4\port.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FreeRTOS\source\queue.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FreeRTOS\source\tasks.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\FreeRTOS\source\timers.c</name>
    </file>
  </group>
  <group>
    <name>middleware</name>
    <file>
      <name>$PROJ_DIR$\..\middleware\soc\cc_io_park.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\middleware\soc\cc_pm_ops.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\middleware\driver\hal\dma_hal.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\middleware\driver\hal\gpio_hal.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\middleware\driver\hal\hw_timer32.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\middleware\driver\hal\interrupt_hal.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\middleware\driver\hal\rtc_hal.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\middleware\driver\spi_drv.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\middleware\driver\hal\spi_hal.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\middleware\driver\uart_drv.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\middleware\driver\hal\uart_hal.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\middleware\driver\hal\util64.c</name>
    </file>
  </group>
  <group>
    <name>My</name>
    <file>
      <name>$PROJ_DIR$\..\My\DHT11.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\My\GY30.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\My\LCD.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\My\PutChar.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\My\Stat_Communicate.c</name>
    </file>
  </group>
  <group>
    <name>oslib</name>
    <file>
      <name>$PROJ_DIR$\..\oslib\osi_freertos.c</name>
    </file>
  </group>
  <group>
    <name>simplelink</name>
    <file>
      <name>$PROJ_DIR$\..\simplelink\cc_pal.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\simplelink\source\device.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\simplelink\source\driver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\simplelink\source\flowcont.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\simplelink\source\fs.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\simplelink\source\netapp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\simplelink\source\netcfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\simplelink\source\nonos.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\simplelink\source\socket.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\simplelink\source\spawn.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\simplelink\source\wlan.c</name>
    </file>
  </group>
  <group>
    <name>user</name>
  </group>
  <file>
    <name>$PROJ_DIR$\..\includes.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\pinmux.c</name>
  </file>
</project>


