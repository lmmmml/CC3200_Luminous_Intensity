# IAR project MyCloudSystem.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: LCD_DISPLAY; ewarm; USE_FREERTOS; SL_PLATFORM_MULTI_THREADED; cc3200
  ICCARM.CCIncludePath2: ..\driverlib; ..\inc; ..; ..\user; ..\common; ..\My; ..\..\Pro_AP\simplelink\include; ..\simplelink; ..\simplelink\include; ..\oslib; ..\FreeRTOS\source\include; ..\FreeRTOS\source; ..\FreeRTOS\source\ARM_CM4; ..\..\Pro_AP\FreeRTOS\source; ..\middleware\driver\hal; ..\middleware\driver; ..\middleware\framework\pm; ..\middleware\framework\timer; ..\middleware\soc; ..\cloud
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MyCloudSystem.bin
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkConfigDefines: CC3200_ES_1_2_1=0
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\TexasInstruments\cc3200.icf
  ILINK.IlinkAdditionalLibs: ..\driverlib\driverlib.a; ..\oslib\free_rtos.a; ..\middleware\middleware.a; ..\simplelink\simplelink.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: Pro1.srec
  group (top)
    ../: includes.h main.c pinmux.c
  group cloud
    ../cloud/: cloud.c cloud_connect.c cloud_pal.c device_status.c smartconfig.c
  group common
    ../common/: button_if.c gpio_if.c i2c_if.c startup_ewarm.c timer_if.c uart_if.c udma_if.c utils_if.c wdt_if.c
  group driverlib
    ../driverlib/: adc.c aes.c camera.c cpu.c crc.c des.c flash.c gpio.c hwspinlock.c i2c.c i2s.c interrupt.c pin.c prcm.c sdhost.c shamd5.c spi.c systick.c timer.c uart.c udma.c utils.c wdt.c
  group FreeRTOS
    ../FreeRTOS/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/source/ARM_CM4/: port.c
  group FreeRTOS/MemMang
    ../FreeRTOS/source/MemMang/: heap_3.c
  group middleware
    ../middleware/soc/: cc_io_park.c cc_pm_ops.c
    ../middleware/driver/hal/: dma_hal.c gpio_hal.c hw_timer32.c interrupt_hal.c rtc_hal.c spi_hal.c uart_hal.c util64.c
    ../middleware/driver/: spi_drv.c uart_drv.c
  group My
    ../My/: DHT11.c GY30.c LCD.c PutChar.c Stat_Communicate.c
  group oslib
    ../oslib/: osi_freertos.c
  group simplelink
    ../simplelink/: cc_pal.c
    ../simplelink/source/: device.c driver.c flowcont.c fs.c netapp.c netcfg.c nonos.c socket.c spawn.c wlan.c
